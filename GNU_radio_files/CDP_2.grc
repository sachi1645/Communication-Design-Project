options:
  parameters:
    author: Lenavo
    generate_options: qt_gui
    id: CDP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''1110000101011010111010001001001111100001010110101110100010010011'''
  states: {}
- name: aes_key
  id: variable
  parameters:
    value: '''9F3C7A12D4E8B5C1A0F2D39B7E5648AF'''
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_crc
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.5'
    samples_per_symbol: '4'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.5'
    samples_per_symbol: '4'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt

      class add_address_block(gr.basic_block):
          """
          Adds a fixed 32-byte PREAMBLE + 1-byte destination address to each PDU.
          Dynamically updatable via 'config' message port.

          Input  PDU format : [ SEQ(1B) | PAYLOAD(32B) | CRC32(4B) ]
          Output PDU format : [ PREAMBLE(32B) | DEST(1B) | SEQ(1B) | PAYLOAD(32B) | CRC32(4B) ]
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Add Preamble + Address",
                  in_sig=None,
                  out_sig=None
              )

              # Initial Address (can be updated dynamically)
              self.address = 0 & 0xFF

              # ---- FIXED 32-BYTE PREAMBLE ----
              self.preamble = [
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6,
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6,
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6,
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6
              ]

              # Message ports
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              
              # NEW: Config port
              self.message_port_register_in(pmt.intern('config'))
              
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('config'), self.handle_config)

          def handle_config(self, msg):
              """ Update destination address dynamically """
              if pmt.is_dict(msg) and pmt.dict_has_key(msg, pmt.intern("dest_addr")):
                  new_addr = pmt.to_long(pmt.dict_ref(msg, pmt.intern("dest_addr"), pmt.PMT_NIL))
                  self.address = new_addr & 0xFF
                  # print(f"[Add Address] Updated Target to: {self.address}")

          def handle_msg(self, pdu):
              if not pmt.is_pair(pdu):
                  return

              meta = pmt.car(pdu)
              payload = pmt.cdr(pdu)

              if not pmt.is_u8vector(payload):
                  return

              # Convert payload to list of ints
              data = list(pmt.u8vector_elements(payload))

              # Build final PDU: PREAMBLE + DEST + original payload
              new_data = self.preamble + [self.address] + data

              # Convert to PMT
              new_payload = pmt.init_u8vector(len(new_data), new_data)

              # Add metadata (optional)
              meta = pmt.dict_add(meta, pmt.intern("dest_addr"),
                                  pmt.from_long(self.address))

              # Publish final PDU
              self.message_port_pub(pmt.intern('out'),
                                    pmt.cons(meta, new_payload))
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: WhatsApp GUI (Menu-Based Address Config + TXT Only)
      """

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime
      import base64
      import os

      # --- 1. VISUAL HELPERS & THEMES ---

      THEMES = {
          "light": {
              "bg_color": "#E5DDD5", "top_bar": "#075E54", "input_area": "#F0F0F0",
              "input_box": "#FFFFFF", "text_primary": "black", "bubble_own": "#DCF8C6",
              "bubble_other": "#FFFFFF", "time_color": "gray", "tick_color": "#4DF0F0",
              "border": "#dcdcdc", "dialog_bg": "#FFFFFF"
          },
          "dark": {
              "bg_color": "#0b141a", "top_bar": "#202c33", "input_area": "#202c33",
              "input_box": "#2a3942", "text_primary": "#e9edef", "bubble_own": "#005c4b",
              "bubble_other": "#202c33", "time_color": "#8696a0", "tick_color": "#53bdeb",
              "border": "#202c33", "dialog_bg": "#2a3942"
          }
      }

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)

      class ConfigDialog(QtWidgets.QDialog):
          """ Small popup to change Source and Dest IDs """
          def __init__(self, current_my, current_target, theme_name, parent=None):
              super().__init__(parent)
              self.setWindowTitle("Configure IDs")
              self.resize(300, 150)
              self.theme = THEMES[theme_name]
              
              # Layout
              layout = QtWidgets.QVBoxLayout(self)
              
              # Inputs
              form_layout = QtWidgets.QFormLayout()
              self.my_input = QtWidgets.QLineEdit(str(current_my))
              self.target_input = QtWidgets.QLineEdit(str(current_target))
              
              lbl_my = QtWidgets.QLabel("My ID (Source):")
              lbl_target = QtWidgets.QLabel("Target ID (Dest):")
              
              form_layout.addRow(lbl_my, self.my_input)
              form_layout.addRow(lbl_target, self.target_input)
              layout.addLayout(form_layout)
              
              # Buttons
              btns = QtWidgets.QDialogButtonBox(QtWidgets.QDialogButtonBox.Ok | QtWidgets.QDialogButtonBox.Cancel)
              btns.accepted.connect(self.accept)
              btns.rejected.connect(self.reject)
              layout.addWidget(btns)
              
              # Styling
              self.setStyleSheet(f"""
                  QDialog {{ background-color: {self.theme['dialog_bg']}; color: {self.theme['text_primary']}; }}
                  QLabel {{ color: {self.theme['text_primary']}; font-weight: bold; }}
                  QLineEdit {{ 
                      background-color: {self.theme['input_box']}; 
                      color: {self.theme['text_primary']}; 
                      border: 1px solid {self.theme['border']}; 
                      padding: 5px; border-radius: 5px;
                  }}
                  QPushButton {{ 
                      background-color: {self.theme['top_bar']}; 
                      color: white; border: none; padding: 8px; border-radius: 4px;
                  }}
              """)

          def get_values(self):
              try:
                  m = int(self.my_input.text())
                  t = int(self.target_input.text())
                  return m, t
              except ValueError:
                  return None, None

      class _GuiPoster(QtCore.QObject):
          rx_sig = QtCore.pyqtSignal(str, int)     
          ack_sig = QtCore.pyqtSignal()            
          file_save_sig = QtCore.pyqtSignal(str, str) 
          def __init__(self): super().__init__()

      # --- 2. MAIN GUI WINDOW ---

      class ChatWindow(QtWidgets.QWidget):
          def __init__(self, send_callback, config_callback, payload_size=32, dest_name="Node A"):
              super(ChatWindow, self).__init__()
              self.send_callback = send_callback
              self.config_callback = config_callback
              self.payload_size = payload_size
              self.dest_name = dest_name
              
              # State tracking for IDs
              self.my_id = 15       # Default
              self.target_id = 20   # Default
              
              self.current_theme = "light" 
              self.chat_history = [] 
              self.pending_confirmations = []
              self.bubble_widgets = [] 

              self.setWindowTitle(f"SDR Chat - {self.dest_name}")
              self.resize(450, 750)
              
              self.main_layout = QtWidgets.QVBoxLayout(self)
              self.main_layout.setContentsMargins(0,0,0,0)
              
              # -- Top Bar --
              self.top_bar = QtWidgets.QFrame()
              top_layout = QtWidgets.QHBoxLayout(self.top_bar)
              top_layout.setContentsMargins(15, 10, 5, 10)
              
              self.header_label = QtWidgets.QLabel(f"👤 {self.dest_name}")
              self.header_label.setStyleSheet("font-size: 18px; font-weight: bold; color: white;")
              
              # Dark Mode Toggle
              self.theme_btn = QtWidgets.QPushButton("🌙")
              self.theme_btn.setFixedSize(35, 35)
              self.theme_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.theme_btn.clicked.connect(self.toggle_theme)
              self.theme_btn.setStyleSheet("QPushButton { background-color: transparent; border: none; font-size: 18px; }")

              # Menu Button (Three Dots)
              self.menu_btn = QtWidgets.QPushButton("⋮")
              self.menu_btn.setFixedSize(35, 35)
              self.menu_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.menu_btn.setStyleSheet("""
                  QPushButton { background-color: transparent; border: none; font-size: 24px; color: white; padding-bottom: 5px; }
                  QPushButton::menu-indicator { image: none; width: 0px; }
              """)
              
              # --- MENU SETUP ---
              self.menu = QtWidgets.QMenu()
              
              # 1. Configure IDs
              self.config_action = self.menu.addAction("⚙️ Configure IDs")
              self.config_action.triggered.connect(self.open_config_dialog)
              
              self.menu.addSeparator()
              
              # 2. Other actions
              export_action = self.menu.addAction("Export Chat Log")
              clear_action = self.menu.addAction("Clear Chat")
              
              export_action.triggered.connect(self.export_chat)
              clear_action.triggered.connect(self.clear_chat)
              
              self.menu_btn.setMenu(self.menu)
              # ------------------

              top_layout.addWidget(self.header_label)
              top_layout.addStretch()
              top_layout.addWidget(self.theme_btn)
              top_layout.addWidget(self.menu_btn)
              self.main_layout.addWidget(self.top_bar)

              # -- Chat Area --
              self.scroll_area = WallpaperScrollArea() 
              self.chat_container = QtWidgets.QWidget()
              self.chat_container.setStyleSheet("background: transparent;")
              self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
              self.chat_layout.setAlignment(QtCore.Qt.AlignTop)
              self.chat_layout.setSpacing(8)
              self.chat_layout.setContentsMargins(15, 15, 15, 15)
              self.scroll_area.setWidget(self.chat_container)
              self.main_layout.addWidget(self.scroll_area)

              # -- Input Area --
              self.input_frame = QtWidgets.QFrame()
              input_layout = QtWidgets.QHBoxLayout(self.input_frame)
              input_layout.setContentsMargins(10, 10, 10, 10)
              
              self.emoji_btn = QtWidgets.QPushButton("😊")
              self.emoji_btn.setFixedSize(40, 40)
              self.emoji_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.emoji_btn.setStyleSheet("""QPushButton { border: none; font-size: 20px; } QPushButton::menu-indicator { image: none; width: 0px; }""")
              
              self.emoji_menu = QtWidgets.QMenu()
              emojis = ["😀", "😂", "👍", "❤️", "📻", "🛰️", "👋", "✅", "⚠️", "🔥"]
              for e in emojis:
                  action = self.emoji_menu.addAction(e)
                  action.triggered.connect(lambda checked, emo=e: self.input_box.insert(emo))
              self.emoji_btn.setMenu(self.emoji_menu)

              self.file_btn = QtWidgets.QPushButton("📎")
              self.file_btn.setFixedSize(40, 40)
              self.file_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.file_btn.setStyleSheet("border: none; font-size: 20px;")
              self.file_btn.clicked.connect(self.handle_file_click)
              
              self.input_box = QtWidgets.QLineEdit()
              self.input_box.setPlaceholderText("Type a message...")
              self.input_box.returnPressed.connect(self.handle_send_click)
              
              self.send_btn = QtWidgets.QPushButton("➤")
              self.send_btn.setFixedSize(45, 45)
              self.send_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.send_btn.setStyleSheet("""
                  QPushButton { background-color: #128C7E; color: white; border-radius: 22px; font-size: 18px; border: none; }
                  QPushButton:hover { background-color: #075E54; }
              """)
              self.send_btn.clicked.connect(self.handle_send_click)

              input_layout.addWidget(self.emoji_btn)
              input_layout.addWidget(self.file_btn)
              input_layout.addWidget(self.input_box)
              input_layout.addWidget(self.send_btn)
              self.main_layout.addWidget(self.input_frame)

              self.apply_theme()

          def open_config_dialog(self):
              """ Opens the dialog to change IDs via the menu """
              dlg = ConfigDialog(self.my_id, self.target_id, self.current_theme, self)
              if dlg.exec_() == QtWidgets.QDialog.Accepted:
                  new_my, new_target = dlg.get_values()
                  if new_my is not None and new_target is not None:
                      self.update_ids(new_my, new_target)

          def update_ids(self, my_id, target_id):
              self.my_id = my_id
              self.target_id = target_id
              
              # Create PMT dict for config
              cfg = pmt.make_dict()
              cfg = pmt.dict_add(cfg, pmt.intern("my_addr"), pmt.from_long(my_id))
              cfg = pmt.dict_add(cfg, pmt.intern("dest_addr"), pmt.from_long(target_id))
              
              # Send config to blocks
              self.config_callback(cfg)
              
              # Update UI
              self.dest_name = f"Node {target_id}"
              self.header_label.setText(f"👤 {self.dest_name}")
              self._add_bubble(f"🔁 System: Updated IDs.\nMy ID: {my_id}\nTarget ID: {target_id}", True, "SYS")

          def toggle_theme(self):
              self.current_theme = "dark" if self.current_theme == "light" else "light"
              self.theme_btn.setText("☀️" if self.current_theme == "dark" else "🌙")
              self.apply_theme()

          def apply_theme(self):
              t = THEMES[self.current_theme]
              self.setStyleSheet(f"QWidget {{ font-family: 'Segoe UI', sans-serif; color: {t['text_primary']}; }}")
              self.top_bar.setStyleSheet(f"background-color: {t['top_bar']}; border: none;")
              self.scroll_area.setStyleSheet(f"border: none; background-color: {t['bg_color']};")
              self.input_frame.setStyleSheet(f"background-color: {t['input_area']}; border-top: 1px solid {t['border']};")
              self.input_box.setStyleSheet(f"""
                  QLineEdit {{ background-color: {t['input_box']}; color: {t['text_primary']}; border: 1px solid {t['border']}; border-radius: 20px; padding: 10px; }}
              """)
              for w in self.bubble_widgets:
                  self._style_bubble(w['bubble'], w['stack'], w['ts'], w['is_own'])

          def _style_bubble(self, bubble_lbl, stack_widget, time_lbl, is_own):
              t = THEMES[self.current_theme]
              bg = t['bubble_own'] if is_own else t['bubble_other']
              bubble_lbl.setStyleSheet(f"background-color: transparent; color: {t['text_primary']}; font-size: 14px;")
              stack_widget.setStyleSheet(f"background-color: {bg}; border-radius: 10px; border: 1px solid {t['border']};")
              current_text = time_lbl.text()
              if "✓✓" in current_text and ("#4DF0F0" in current_text or "#53bdeb" in current_text): pass 
              else: time_lbl.setStyleSheet(f"color: {t['time_color']}; font-size: 11px; margin-top: 4px; background-color: transparent;")

          def export_chat(self):
              filename, _ = QtWidgets.QFileDialog.getSaveFileName(self, "Save Chat Log", "", "Text Files (*.txt)")
              if filename:
                  try:
                      with open(filename, 'w', encoding='utf-8') as f:
                          f.write(f"--- Chat Log with {self.dest_name} ---\n")
                          for msg in self.chat_history:
                              sender = "ME" if msg['is_own'] else self.dest_name
                              f.write(f"[{msg['time']}] {sender}: {msg['text']}\n")
                  except: pass

          def clear_chat(self):
              self.chat_history = []
              self.pending_confirmations = []
              self.bubble_widgets = []
              while self.chat_layout.count():
                  item = self.chat_layout.takeAt(0)
                  if item.widget(): item.widget().deleteLater()

          def handle_send_click(self):
              text = self.input_box.text()
              if not text: return
              self._process_outgoing(text, is_file=False)
              self.input_box.clear()

          def handle_file_click(self):
              # 1. Update filter to suggest .txt files
              path, _ = QtWidgets.QFileDialog.getOpenFileName(self, "Select Text File", "", "Text Files (*.txt);;All Files (*)")
              if not path: return
              
              filename = os.path.basename(path)

              # 2. VALIDATION: Check if it ends with .txt
              if not filename.lower().endswith(".txt"):
                  # Display System Error Bubble
                  self._add_bubble(f"⚠️ System: Only .txt files are supported!\nYou selected: {filename}", True, "SYS")
                  return

              # 3. Proceed if valid
              try:
                  with open(path, "rb") as f: 
                      b64 = base64.b64encode(f.read()).decode('utf-8')
                  self._process_outgoing(f"FILE:{filename}:{b64}", is_file=True, filename=filename)
              except: pass

          def _process_outgoing(self, data_str, is_file=False, filename=""):
              chunk_cap = self.payload_size - 1
              data_len = len(data_str.encode("utf-8", "ignore"))
              num_chunks = (data_len + chunk_cap - 1) // chunk_cap
              if num_chunks == 0: num_chunks = 1
              disp = f"📎 Sending File: {filename}..." if is_file else data_str
              time_str = datetime.now().strftime("%H:%M")
              self.chat_history.append({'text': disp, 'is_own': True, 'time': time_str})
              ts = self._add_bubble(disp, is_own=True, time_str=time_str)
              self.pending_confirmations.append({'widget': ts, 'remaining': num_chunks, 'completed': False})
              self.send_callback(data_str)

          def on_rx_message(self, text, seq):
              disp = text
              if text.startswith("FILE:"):
                  try: disp = f"📎 Received File: {text.split(':', 2)[1]} (Saved)"
                  except: disp = "📎 Received Corrupted File"
              time_str = datetime.now().strftime("%H:%M")
              self.chat_history.append({'text': disp, 'is_own': False, 'time': time_str})
              self._add_bubble(disp, is_own=False, time_str=time_str)

          def on_ack_received(self):
              for item in self.pending_confirmations:
                  if not item['completed']:
                      if item['remaining'] > 0:
                          item['remaining'] -= 1
                          if item['remaining'] == 0:
                              item['completed'] = True
                              t = THEMES[self.current_theme]
                              now = datetime.now().strftime("%H:%M")
                              item['widget'].setText(f"{now} <span style='color: {t['tick_color']}; font-weight: bold;'>✓✓</span>")
                      return

          def _add_bubble(self, text, is_own, time_str):
              row = QtWidgets.QWidget()
              layout = QtWidgets.QHBoxLayout(row)
              layout.setContentsMargins(0,0,0,0)
              bubble = QtWidgets.QLabel(text)
              bubble.setWordWrap(True)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              
              ts_html = f"{time_str} <span style='color: gray; font-weight: bold;'>✓✓</span>" if is_own else time_str
              ts = QtWidgets.QLabel(ts_html)
              ts.setAlignment(QtCore.Qt.AlignRight)
              ts.setTextFormat(QtCore.Qt.RichText)

              stack = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout(stack)
              vbox.setContentsMargins(8,8,8,5)
              vbox.addWidget(bubble)
              vbox.addWidget(ts)
              
              shadow = QtWidgets.QGraphicsDropShadowEffect()
              shadow.setBlurRadius(5)
              shadow.setXOffset(1)
              shadow.setYOffset(1)
              shadow.setColor(QtGui.QColor(0, 0, 0, 40))
              stack.setGraphicsEffect(shadow)

              self._style_bubble(bubble, stack, ts, is_own)
              self.bubble_widgets.append({'bubble': bubble, 'stack': stack, 'ts': ts, 'is_own': is_own})

              if is_own: 
                  layout.addStretch()
                  layout.addWidget(stack)
              else: 
                  layout.addWidget(stack)
                  layout.addStretch()
              self.chat_layout.addWidget(row)
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(10, lambda: self.scroll_area.verticalScrollBar().setValue(self.scroll_area.verticalScrollBar().maximum()))
              return ts

      # --- 3. GNU RADIO BLOCK ---

      class chat_gui_block(gr.basic_block):
          def __init__(self, payload_size=32):
              gr.basic_block.__init__(self, name="WhatsApp Chat GUI", in_sig=None, out_sig=None)
              self.payload_size = payload_size
              self.rx_buffer = b""            
              self.last_radio_seq_seen = -1 
              self.last_ack_val_seen = -1
              self.dummy_seq = 0
              
              # Message Ports
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_in(pmt.intern("in"))      
              self.message_port_register_in(pmt.intern("ack_in"))
              self.message_port_register_out(pmt.intern("config_out")) # Config Port
              
              self.set_msg_handler(pmt.intern("in"), self.handle_rx_msg)
              self.set_msg_handler(pmt.intern("ack_in"), self.handle_ack_msg)
              
              self._poster = _GuiPoster()
              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp: self.qapp = QtWidgets.QApplication(sys.argv)
              
              # GUI
              self.gui = ChatWindow(self.send_pdus, self.publish_config, payload_size=self.payload_size, dest_name=str(0))
              
              self._poster.rx_sig.connect(self.gui.on_rx_message)
              self._poster.ack_sig.connect(self.gui.on_ack_received)
              self._poster.file_save_sig.connect(self._save_file_on_disk)
              self.gui.show()

          def publish_config(self, pmt_msg):
              self.message_port_pub(pmt.intern("config_out"), pmt_msg)

          def send_pdus(self, text):
              data = text.encode("utf-8", "ignore")
              chunk_size = self.payload_size - 1
              chunks = [data[i:i+chunk_size] for i in range(0, len(data), chunk_size)]
              if not chunks: chunks = [b'']
              for i, chunk in enumerate(chunks):
                  header = 0x01 if i == len(chunks) - 1 else 0x00
                  payload = bytes([header]) + chunk
                  if len(payload) < self.payload_size: payload += b'\x00' * (self.payload_size - len(payload))
                  meta = pmt.make_dict()
                  pmt.dict_add(meta, pmt.intern("seq"), pmt.from_long(self.dummy_seq))
                  self.dummy_seq = (self.dummy_seq + 1) % 256
                  vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("out"), pmt.cons(meta, vec))

          def handle_rx_msg(self, pdu):
              if not pmt.is_pair(pdu): return
              meta = pmt.car(pdu)
              payload = pmt.cdr(pdu)
              if not pmt.is_u8vector(payload): return
              seq = -1
              if pmt.dict_has_key(meta, pmt.intern("seq")):
                  try: seq = pmt.to_python(pmt.dict_ref(meta, pmt.intern("seq"), pmt.PMT_NIL))
                  except: pass
              if seq != -1:
                  if seq == self.last_radio_seq_seen: return 
                  self.last_radio_seq_seen = seq
              data = bytes(pmt.u8vector_elements(payload))
              if len(data) > 0:
                  header, content = data[0], data[1:]
                  self.rx_buffer += content.rstrip(b'\x00')
                  if header == 0x01:
                      try:
                          txt = self.rx_buffer.decode('utf-8', 'ignore')
                          self._poster.rx_sig.emit(txt, seq)
                          if txt.startswith("FILE:"):
                              parts = txt.split(":", 2)
                              self._poster.file_save_sig.emit(parts[1], parts[2])
                      except: pass
                      self.rx_buffer = b""

          def handle_ack_msg(self, pdu):
              if not pmt.is_pair(pdu): return
              meta = pmt.car(pdu)
              payload = pmt.cdr(pdu)
              ack_seq = -1
              if pmt.dict_has_key(meta, pmt.intern("ack")):
                  try: ack_seq = pmt.to_python(pmt.dict_ref(meta, pmt.intern("ack"), pmt.PMT_NIL))
                  except: pass
              elif pmt.is_u8vector(payload):
                  data = bytes(pmt.u8vector_elements(payload))
                  if len(data) > 0: ack_seq = int(data[0])
              if ack_seq != -1:
                  if ack_seq == self.last_ack_val_seen: return
                  self.last_ack_val_seen = ack_seq
                  self._poster.ack_sig.emit()

          def _save_file_on_disk(self, fname, b64_data):
              if not os.path.exists("downloads"): os.makedirs("downloads")
              try:
                  with open(os.path.join("downloads", fname), "wb") as f: f.write(base64.b64decode(b64_data))
              except: pass

          def stop(self):
              self.gui.close()
              return super().stop()
    payload_size: '32'
  states: {}
- name: epy_block_10
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, threading, time
      from collections import deque

      class payload_to_pdu_with_seq_arq(gr.basic_block):
          """
          PAYLOAD PDU → PDU with SEQ + Stop-and-Wait ARQ

          Input PDU (port 'in'):
            Meta: (ignored or optional)
            Payload: PAYLOAD(payload_size bytes) – will be padded/truncated to fit.

          Output PDU (port 'out'):
            Frame = [ SEQ(1 byte) | PAYLOAD(payload_size bytes) ]
            Meta:
              - 'seq': sequence number (0..255)

          ACK rule (same as before):
            If TX sent SEQ=s, wait for ACK=(s+1) mod 256 before sending next.

          Accepted ACKs on 'ack_in':
            • Meta dict: {'ack': <int 0..255>}
            • Payload: single byte (first byte used)

          Parameters:
            payload_size : normally 32
            wait_time_s  : timeout for ACK and retry pacing
            max_retries  : number of retransmissions before giving up
            verbose      : print debug log
          """

          def __init__(self, payload_size=32, wait_time_s=0.1,
                       max_retries=10, verbose=True):
              gr.basic_block.__init__(self,
                                      name="Payload to PDU with SEQ+ARQ",
                                      in_sig=None,
                                      out_sig=None)

              self.payload_size = int(payload_size)
              self.wait_time_s  = float(wait_time_s)
              self.max_retries  = int(max_retries)
              self.verbose      = bool(verbose)

              # Message ports
              self.message_port_register_in(pmt.intern("in"))       # payload PDUs
              self.message_port_register_in(pmt.intern("ack_in"))   # ACKs
              self.message_port_register_out(pmt.intern("out"))     # final framed PDUs

              self.set_msg_handler(pmt.intern("in"),     self._handle_payload)
              self.set_msg_handler(pmt.intern("ack_in"), self._handle_ack)

              # State
              self._run       = threading.Event()
              self._tx_thread = None

              self._seq       = 0
              self._last_ack  = None

              # Queue of pending payloads (bytes objects, length = payload_size)
              self._pending_payloads = deque()
              self._payload_cv = threading.Condition()
              self._ack_cv     = threading.Condition()

          # ----- logger -----
          def _log(self, msg):
              if self.verbose:
                  print(f"[payload_to_pdu_with_seq_arq] {msg}")

          # ----- lifecycle -----
          def start(self):
              self._run.set()
              self._tx_thread = threading.Thread(target=self._tx_loop, daemon=True)
              self._tx_thread.start()
              self._log("TX thread started")
              return super().start()

          def stop(self):
              self._run.clear()
              with self._payload_cv:
                  self._payload_cv.notify_all()
              with self._ack_cv:
                  self._ack_cv.notify_all()
              if self._tx_thread:
                  self._tx_thread.join(timeout=1.0)
              self._log("TX thread stopped")
              return super().stop()

          # ----- payload input handler -----
          def _handle_payload(self, pdu):
              """
              Accepts PDUs from the first block.
              Payload is normalized to exactly payload_size bytes
              (pad with 0x00 or truncate if needed).
              """
              if not pmt.is_pair(pdu):
                  return

              meta, pl = pmt.car(pdu), pmt.cdr(pdu)

              if not pmt.is_u8vector(pl):
                  return

              data = bytes(pmt.u8vector_elements(pl))

              # Normalize to fixed payload_size
              if len(data) < self.payload_size:
                  data = data + b"\x00" * (self.payload_size - len(data))
              elif len(data) > self.payload_size:
                  data = data[:self.payload_size]

              with self._payload_cv:
                  self._pending_payloads.append(data)
                  self._payload_cv.notify()

              self._log(f"Queued payload (len={len(data)} bytes), queue size={len(self._pending_payloads)}")

          # ----- ACK handler (same logic as original) -----
          def _handle_ack(self, pdu):
              ack_val = None
              if pmt.is_pair(pdu):
                  meta, pl = pmt.car(pdu), pmt.cdr(pdu)
                  # meta-based ACK
                  if pmt.is_dict(meta):
                      k = pmt.intern("ack")
                      if pmt.dict_has_key(meta, k):
                          try:
                              v = pmt.to_python(pmt.dict_ref(meta, k, pmt.PMT_NIL))
                              if isinstance(v, int):
                                  ack_val = v & 0xFF
                          except Exception:
                              pass
                  # payload-based ACK (first byte)
                  if ack_val is None and pmt.is_u8vector(pl):
                      data = bytes(pmt.u8vector_elements(pl))
                      if len(data) >= 1:
                          ack_val = data[0] & 0xFF

              if ack_val is not None:
                  with self._ack_cv:
                      self._last_ack = ack_val
                      self._ack_cv.notify_all()
                  self._log(f"Received ACK={ack_val}")

          # ----- TX loop with Stop-and-Wait ARQ -----
          def _tx_loop(self):
              while self._run.is_set():
                  # 1) Get next payload from queue
                  with self._payload_cv:
                      while self._run.is_set() and not self._pending_payloads:
                          self._payload_cv.wait(timeout=0.1)

                      if not self._run.is_set():
                          break

                      payload = self._pending_payloads.popleft()

                  seq = self._seq
                  expected_ack = (seq + 1) & 0xFF
                  frame = bytes([seq]) + payload

                  retries = 0
                  got_ack = False
                  self._log(f"TX seq={seq}, expecting ACK={expected_ack}")

                  # 2) Stop-and-Wait ARQ logic for this payload
                  while self._run.is_set() and not got_ack:
                      # Send packet
                      self._publish(frame)

                      # Wait for ACK
                      deadline = time.monotonic() + self.wait_time_s
                      while self._run.is_set() and time.monotonic() < deadline:
                          with self._ack_cv:
                              remaining = max(0.0, deadline - time.monotonic())
                              self._ack_cv.wait(timeout=remaining)
                              if self._last_ack == expected_ack:
                                  got_ack = True
                                  self._log(f"ACK={expected_ack} OK for seq={seq}")
                                  break

                      if not got_ack:
                          retries += 1
                          if retries <= self.max_retries:
                              self._log(f"Timeout waiting for ACK={expected_ack} (seq={seq}), retry {retries}/{self.max_retries}")
                          if retries > self.max_retries:
                              self._log(f"[ARQ] No ACK for seq={seq}, giving up after {self.max_retries} retries")
                              got_ack = True  # give up and proceed

                  # 3) Advance sequence number after we're done with this payload
                  self._seq = expected_ack

              self._log("TX loop exiting")

          # ----- Publish final framed PDU -----
          def _publish(self, frame: bytes):
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("seq"), pmt.from_long(frame[0]))
              payload_list = list(frame)
              payload_pmt = pmt.init_u8vector(len(payload_list), payload_list)
              self.message_port_pub(pmt.intern("out"), pmt.cons(meta, payload_pmt))
    max_retries: '10'
    payload_size: '40'
    verbose: 'True'
    wait_time_s: '0.3'
  states: {}
- name: epy_block_11
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, zlib

      class crc32_verify_and_ack(gr.basic_block):
          """
          CRC32 Verify & ACK
          ----------------------------------------------------------------
          Input  PDU : [ SEQ(1B) | PAYLOAD(40B) | CRC32(4B, big-endian) ]
          PAYLOAD   : [ NONCE(8B) | CIPHERTEXT(32B) ]
          CRC over  : [ SEQ | PAYLOAD ]  -> total 41 bytes

          On CRC pass:
            - 'out'     → PAYLOAD only (40 bytes),
                          meta: {crc_ok=True, seq=<seq>, ...}
            - 'ack_out' → payload: [ NEXT_SEQ(1B) | PAYLOAD(40B) ]  (41 bytes)
                          meta:   {ack=<next_seq>, crc_ok=True}

          On CRC fail:
            - 'drop'    → diagnostic PDU with {crc_ok=False, drop_reason=...}

          Parameters
            variant : "ieee"  (init/xor=0xFFFFFFFF, reflected)
                      "zlib"  (init/xor=0x00000000, reflected)
          """

          def __init__(self, variant="ieee"):
              gr.basic_block.__init__(self, name="CRC32 Verifier",
                                      in_sig=None, out_sig=None)
              self.variant = str(variant).lower().strip()
              if self.variant not in ("ieee", "zlib"):
                  self.variant = "ieee"

              # Fixed payload length: 40 bytes (8B nonce + 32B ciphertext)
              self.payload_len = 40

              # Ports
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self._handle)
              self.message_port_register_out(pmt.intern('out'))      # 40B payload only
              self.message_port_register_out(pmt.intern('ack_out'))  # NEXT_SEQ + PAYLOAD
              self.message_port_register_out(pmt.intern('drop'))     # diagnostics

          # CRC engines
          def _crc32(self, data: bytes) -> int:
              if self.variant == "ieee":
                  # CRC-32/IEEE 802.3: reflected, init=0xFFFFFFFF, xorout=0xFFFFFFFF
                  return (zlib.crc32(data, 0xFFFFFFFF) ^ 0xFFFFFFFF) & 0xFFFFFFFF
              else:
                  # zlib default: reflected, init=0x00000000, xorout=0x00000000
                  return zlib.crc32(data) & 0xFFFFFFFF

          def _handle(self, pdu):
              if not pmt.is_pair(pdu):
                  return
              meta, pl = pmt.car(pdu), pmt.cdr(pdu)
              if not pmt.is_u8vector(pl):
                  return

              buf = bytes(pmt.u8vector_elements(pl))

              # Expect exactly SEQ(1) + PAYLOAD(40) + CRC(4) = 45 bytes
              expected_len = 1 + self.payload_len + 4
              if len(buf) < expected_len:
                  self._emit_drop(meta, buf, "short_frame")
                  return

              body   = buf[:-4]  # [SEQ | PAYLOAD]
              crc_rx = int.from_bytes(buf[-4:], byteorder='big')

              # Expect exactly 1 + payload_len bytes in body
              if len(body) != 1 + self.payload_len:
                  self._emit_drop(meta, buf, "bad_payload_len")
                  return

              seq     = body[0]
              payload = body[1:]  # 40 bytes: [NONCE(8) | CIPHERTEXT(32)]

              if self._crc32(body) != crc_rx:
                  self._emit_drop(meta, buf, "crc_fail")
                  return

              # ---- Publish PAYLOAD only on 'out' (40B) ----
              out_meta = meta
              try:
                  out_meta = pmt.dict_add(out_meta, pmt.intern("crc_ok"), pmt.from_bool(True))
                  out_meta = pmt.dict_add(out_meta, pmt.intern("seq"),    pmt.from_long(int(seq)))
              except Exception:
                  pass

              self.message_port_pub(
                  pmt.intern('out'),
                  pmt.cons(out_meta, pmt.init_u8vector(len(payload), list(payload)))
              )

              # ---- Publish ACK: [ NEXT_SEQ | PAYLOAD(40B) ] ----
              ack_next = (seq + 1) & 0xFF
              ack_meta = pmt.make_dict()
              try:
                  ack_meta = pmt.dict_add(ack_meta, pmt.intern("ack"),    pmt.from_long(ack_next))
                  ack_meta = pmt.dict_add(ack_meta, pmt.intern("crc_ok"), pmt.from_bool(True))
              except Exception:
                  pass

              ack_bytes = [ack_next] + list(payload)  # 1 + 40 = 41 bytes
              self.message_port_pub(
                  pmt.intern('ack_out'),
                  pmt.cons(ack_meta, pmt.init_u8vector(len(ack_bytes), ack_bytes))
              )

          def _emit_drop(self, meta, data_bytes, reason):
              try:
                  m = meta
                  if not pmt.is_dict(m):
                      m = pmt.make_dict()
                  m = pmt.dict_add(m, pmt.intern("crc_ok"),      pmt.from_bool(False))
                  m = pmt.dict_add(m, pmt.intern("drop_reason"), pmt.intern(str(reason)))
                  v = pmt.init_u8vector(len(data_bytes), list(data_bytes))
                  self.message_port_pub(pmt.intern('drop'), pmt.cons(m, v))
              except Exception:
                  pass
    variant: '"zlib"'
  states: {}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, zlib

      class ack_crc32_verify_minimal(gr.basic_block):
          """
          ACK CRC32 Verify (Minimal, 1-byte ACK)
          -------------------------------------
          Input PDU (port 'in'):
              Payload: [ NEXT_SEQ(1B) | PAYLOAD(40B) | CRC32(4B, big-endian) ]
              CRC over: [ NEXT_SEQ | PAYLOAD ]  (1 + 40 = 41 bytes)

          On CRC pass:
              → 'ack_out': PDU with
                   meta:    { ack: NEXT_SEQ, crc_ok: True }
                   payload: [ NEXT_SEQ ]  (1 byte)

          On CRC fail:
              → 'drop': PDU with original frame and meta:
                   { crc_ok: False, drop_reason: "crc_fail" or "bad_len" }

          Parameters
            variant : "ieee"  (init/xor=0xFFFFFFFF, reflected)
                      "zlib"  (init/xor=0x00000000, reflected)
          """

          def __init__(self, variant="ieee"):
              gr.basic_block.__init__(self,
                                      name="CRC32 Verifier ACK",
                                      in_sig=None,
                                      out_sig=None)

              self.variant = str(variant).lower().strip()
              if self.variant not in ("ieee", "zlib"):
                  self.variant = "ieee"

              # Expected payload layout: 1 (next_seq) + 40 (payload) + 4 (crc32)
              self.payload_len = 40

              # Ports
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self._handle)

              self.message_port_register_out(pmt.intern("ack_out"))
              self.message_port_register_out(pmt.intern("drop"))

          # --- CRC helper ---
          def _crc32(self, data: bytes) -> int:
              if self.variant == "ieee":
                  # CRC-32/IEEE 802.3: reflected, init=0xFFFFFFFF, xorout=0xFFFFFFFF
                  return (zlib.crc32(data, 0xFFFFFFFF) ^ 0xFFFFFFFF) & 0xFFFFFFFF
              else:
                  # zlib default: reflected, init=0x00000000, xorout=0x00000000
                  return zlib.crc32(data) & 0xFFFFFFFF

          # --- main handler ---
          def _handle(self, pdu):
              if not pmt.is_pair(pdu):
                  return

              meta, pl = pmt.car(pdu), pmt.cdr(pdu)
              if not pmt.is_u8vector(pl):
                  return

              buf = bytes(pmt.u8vector_elements(pl))

              # Expect exactly NEXT_SEQ(1) + PAYLOAD(40) + CRC32(4) = 45 bytes
              expected_len = 1 + self.payload_len + 4
              if len(buf) != expected_len:
                  self._emit_drop(meta, buf, "bad_len")
                  return

              body   = buf[:-4]                         # [ NEXT_SEQ | PAYLOAD(40B) ]
              crc_rx = int.from_bytes(buf[-4:], "big")
              next_seq = body[0]

              if self._crc32(body) != crc_rx:
                  self._emit_drop(meta, buf, "crc_fail")
                  return

              # --- Publish 1-byte ACK PDU ---
              ack_meta = pmt.make_dict()
              try:
                  ack_meta = pmt.dict_add(ack_meta, pmt.intern("ack"),
                                          pmt.from_long(int(next_seq)))
                  ack_meta = pmt.dict_add(ack_meta, pmt.intern("crc_ok"),
                                          pmt.from_bool(True))
              except Exception:
                  pass

              ack_payload = [int(next_seq) & 0xFF]
              self.message_port_pub(
                  pmt.intern("ack_out"),
                  pmt.cons(ack_meta, pmt.init_u8vector(1, ack_payload))
              )

          def _emit_drop(self, meta, data_bytes, reason):
              try:
                  m = meta
                  if not pmt.is_dict(m):
                      m = pmt.make_dict()
                  m = pmt.dict_add(m, pmt.intern("crc_ok"), pmt.from_bool(False))
                  m = pmt.dict_add(m, pmt.intern("drop_reason"),
                                   pmt.intern(str(reason)))
                  v = pmt.init_u8vector(len(data_bytes), list(data_bytes))
                  self.message_port_pub(pmt.intern("drop"), pmt.cons(m, v))
              except Exception:
                  pass
    variant: '"zlib"'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt

      class add_ack_address_block(gr.basic_block):
          """
          Add 32-byte PREAMBLE + DEST Address to ACK Frames
          Dynamically updatable via 'config' message port.

          Output structure:
            [ PREAMBLE(32 bytes) | DEST(1 byte) | ACK_PAYLOAD(...) ]

          Parameters:
            dest_addr : destination address for ACK (0–255)
                        (This is the TARGET ID you are sending ACKs to)
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Add ACK Preamble + Address",
                  in_sig=None,
                  out_sig=None)

              # 1-byte destination address (The ID of the person you are chatting with)
              self.dest_addr = 0 & 0xFF

              # ---- SAME 32-BYTE PREAMBLE AS TRANSMITTER ----
              self.preamble = [
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6,
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6,
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6,
                  0xD3, 0x42, 0xA1, 0x7F, 0x9C, 0xE2, 0x55, 0xAA,
                  0x13, 0x87, 0x4E, 0xB1, 0x2C, 0xF0, 0x99, 0x6D,
                  0x3A, 0xC4, 0x1F, 0x82, 0x5B, 0xD8, 0x66, 0xE7,
                  0x24, 0x91, 0x7C, 0x0B, 0x38, 0xF2, 0x4D, 0xC6
              ]

              # Register ports
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              
              # NEW: Config port
              self.message_port_register_in(pmt.intern('config'))
              
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('config'), self.handle_config)

          def handle_config(self, msg):
              """ Update destination address dynamically from GUI """
              # The GUI sends a dict with {'dest_addr': X, 'my_addr': Y}
              # For ACKs, we need to send TO the 'dest_addr'
              if pmt.is_dict(msg) and pmt.dict_has_key(msg, pmt.intern("my_addr")):
                  new_addr = pmt.to_long(pmt.dict_ref(msg, pmt.intern("my_addr"), pmt.PMT_NIL))
                  self.dest_addr = new_addr & 0xFF

          def handle_msg(self, pdu):
              if not pmt.is_pair(pdu):
                  return

              meta = pmt.car(pdu)
              payload = pmt.cdr(pdu)

              if not pmt.is_u8vector(payload):
                  return

              # Convert payload to a list of ints
              data = list(pmt.u8vector_elements(payload))

              # Build final ACK frame:
              # [ PREAMBLE | DEST | ORIGINAL_ACK_DATA ]
              new_frame = self.preamble + [self.dest_addr] + data

              # Add metadata (optional)
              new_meta = meta
              try:
                  new_meta = pmt.dict_add(new_meta, pmt.intern("my_addr"),
                                          pmt.from_long(self.dest_addr))
              except Exception:
                  pass

              # Convert back to PMT
              new_payload_pmt = pmt.init_u8vector(len(new_frame), new_frame)

              # Publish new ACK PDU
              self.message_port_pub(pmt.intern('out'),
                                    pmt.cons(new_meta, new_payload_pmt))
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt

      class address_filter_rx(gr.basic_block):
          """
          Address Filter (RX) with preamble stripping
          Dynamically updatable via 'config' message port.

          Expects PDU payload:
            [ PREAMBLE(NB) | DEST(1B) | SEQ(1B) | PAYLOAD(...) | CRC32(4B) ]

          Behavior:
            - Strips PREAMBLE and DEST
            - Only forwards if DEST == my_addr
            - Updates 'my_addr' dynamically via 'config' port
          """

          def __init__(self, preamble_len=32):
              gr.basic_block.__init__(self, name="Address Filter", in_sig=None, out_sig=None)
              
              # Initial Address (can be updated dynamically)
              self.my_addr = 0 & 0xFF
              self.preamble_len = int(preamble_len)

              # Message ports
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_out(pmt.intern('drop'))
              
              # NEW: Config port
              self.message_port_register_in(pmt.intern('config'))
              
              self.set_msg_handler(pmt.intern('in'), self._handle)
              self.set_msg_handler(pmt.intern('config'), self.handle_config)

          def handle_config(self, msg):
              """ Update 'My Address' dynamically """
              if pmt.is_dict(msg) and pmt.dict_has_key(msg, pmt.intern("dest_addr")):
                  new_addr = pmt.to_long(pmt.dict_ref(msg, pmt.intern("dest_addr"), pmt.PMT_NIL))
                  self.my_addr = new_addr & 0xFF
                  # print(f"[Address Filter] Updated My Address to: {self.my_addr}")

          def _handle(self, pdu):
              if not pmt.is_pair(pdu):
                  return

              meta = pmt.car(pdu)
              pl = pmt.cdr(pdu)

              if not pmt.is_u8vector(pl):
                  return

              data = bytes(pmt.u8vector_elements(pl))

              # Need at least: PREAMBLE + DEST + SEQ + CRC32
              min_len = self.preamble_len + 1 + 1 + 4
              if len(data) < min_len:
                  self._emit_drop(meta, data, reason="short_frame")
                  return

              # Strip preamble first
              frame = data[self.preamble_len:]      # [ DEST | SEQ | PAYLOAD | CRC32 ]
              dest = frame[0]

              # CHECK ADDRESS
              if dest != self.my_addr:
                  self._emit_drop(meta, data, reason="addr_mismatch")
                  return

              # Strip DEST: output [ SEQ | PAYLOAD | CRC32 ]
              fwd = frame[1:]
              if len(fwd) < 1 + 4:  # SEQ + CRC32 at minimum
                  self._emit_drop(meta, data, reason="short_after_strip")
                  return

              seq = fwd[0]

              # Add useful metadata
              out_meta = meta
              try:
                  out_meta = pmt.dict_add(out_meta, pmt.intern("dest_addr"), pmt.from_long(dest))
                  out_meta = pmt.dict_add(out_meta, pmt.intern("seq"), pmt.from_long(seq))
                  out_meta = pmt.dict_add(out_meta, pmt.intern("packet_len"), pmt.from_long(len(fwd)))
              except Exception:
                  pass

              # Publish stripped frame
              out_vec = pmt.init_u8vector(len(fwd), list(fwd))
              self.message_port_pub(pmt.intern('out'), pmt.cons(out_meta, out_vec))

          def _emit_drop(self, meta, data_bytes, reason="drop"):
              try:
                  # Try to extract DEST as seen on the air (after preamble, if present)
                  if len(data_bytes) > self.preamble_len:
                      dest_seen = data_bytes[self.preamble_len]
                  else:
                      dest_seen = -1

                  m = pmt.dict_add(meta, pmt.intern("drop_reason"), pmt.intern(reason))
                  m = pmt.dict_add(m, pmt.intern("dest_seen"), pmt.from_long(dest_seen))
                  v = pmt.init_u8vector(len(data_bytes), list(data_bytes))
                  self.message_port_pub(pmt.intern('drop'), pmt.cons(m, v))
              except Exception:
                  pass
    preamble_len: '128'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      import os

      class pdu_aes_encrypt(gr.basic_block):
          """
          PDU AES Encrypt (AES-CTR)

          In:
            - PDU: (meta, payload_bytes)

          Out:
            - PDU: same meta
                    payload = NONCE(8 bytes) | CIPHERTEXT(len(payload_bytes))

          Parameters:
            key_hex : AES key in hex (16/24/32 bytes => 32/48/64 hex chars)
            verbose : print debug
          """

          def __init__(self, key_hex="00112233445566778899AABBCCDDEEFF", verbose=True):
              gr.basic_block.__init__(self,
                                      name="PDU AES Encrypt (CTR)",
                                      in_sig=None,
                                      out_sig=None)

              self.verbose = bool(verbose)
              self.set_key_hex(key_hex)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self._handle_msg)

          def _log(self, msg):
              if self.verbose:
                  print(f"[pdu_aes_encrypt] {msg}")

          # ---- key handling ----
          def set_key_hex(self, key_hex):
              """
              Set AES key as hex string (32/48/64 hex chars).
              Can be used as a GRC callback.
              """
              key_hex = key_hex.replace(" ", "")
              try:
                  key = bytes.fromhex(key_hex)
              except ValueError:
                  raise ValueError("key_hex must be valid hex")

              if len(key) not in (16, 24, 32):
                  raise ValueError("AES key must be 16, 24, or 32 bytes (32/48/64 hex chars)")

              self._key = key
              self._log(f"Key set ({len(key)} bytes)")

          # ---- message handler ----
          def _handle_msg(self, pdu):
              if not pmt.is_pair(pdu):
                  return

              meta = pmt.car(pdu)
              pl   = pmt.cdr(pdu)

              if not pmt.is_u8vector(pl):
                  self._log("Ignoring non-u8vector payload")
                  return

              plaintext = bytes(pmt.u8vector_elements(pl))

              # Generate random nonce (8 bytes) for AES-CTR
              nonce = os.urandom(8)

              cipher = AES.new(self._key, AES.MODE_CTR, nonce=nonce)
              ciphertext = cipher.encrypt(plaintext)

              out_bytes = nonce + ciphertext

              payload_pmt = pmt.init_u8vector(len(out_bytes), list(out_bytes))
              out_pdu = pmt.cons(meta, payload_pmt)
              self.message_port_pub(pmt.intern("out"), out_pdu)

              self._log(f"Encrypted PDU: in_len={len(plaintext)}, out_len={len(out_bytes)}")
    key_hex: aes_key
    verbose: 'False'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt, os, threading

      class pdu_payload_to_file(gr.basic_block):
          """
          PDU Payload → File
          ------------------
          Input  PDUs (from crc32_verify_and_ack.out): [ PAYLOAD(32B) ] with meta {seq, packet_len=32, crc_ok=True}
          Action: Appends PAYLOAD to a file, once per new sequence number.
                  On stop (or CTRL "FLUSH"), optionally trims trailing 0x00 bytes (padding).

          Parameters
          ----------
          output_path : str   Path to output file (use r\"D:\\path\\out.txt\" on Windows)
          overwrite   : int   1 = truncate on start, 0 = append if file exists  (default 1)
          strip_zeros_on_close : int  1 = rstrip(b\"\\x00\") at close/flush     (default 1)
          expect_seq_start : int  Expected first seq (default 0). Used only for logging/duplicate detection.

          Ports
          -----
          in    : PDU input  (payload only)
          ctrl  : PDU input  (optional commands: b\"RESET\", b\"FLUSH\", b\"CLOSE\")
          log   : PDU output (optional status messages)
          """

          def __init__(self, output_path="/tmp/out.txt", overwrite=1, strip_zeros_on_close=1, expect_seq_start=0):
              gr.basic_block.__init__(self, name="File Source", in_sig=None, out_sig=None)

              self.output_path = str(output_path)
              self.overwrite = bool(int(overwrite))
              self.strip_zeros_on_close = bool(int(strip_zeros_on_close))
              self.expect_seq = int(expect_seq_start) & 0xFF

              # state
              self._f = None
              self._lock = threading.Lock()
              self._last_written_seq = None    # to detect duplicates
              self._closed = False

              # ports
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self._handle_in)

              self.message_port_register_in(pmt.intern('ctrl'))
              self.set_msg_handler(pmt.intern('ctrl'), self._handle_ctrl)

              self.message_port_register_out(pmt.intern('log'))

          # ---------- lifecycle ----------
          def start(self):
              self._open_file()
              return super().start()

          def stop(self):
              self._finalize_file(trim=self.strip_zeros_on_close)
              return super().stop()

          # ---------- file helpers ----------
          def _open_file(self):
              with self._lock:
                  os.makedirs(os.path.dirname(self.output_path), exist_ok=True) if os.path.dirname(self.output_path) else None
                  mode = "wb" if self.overwrite else "ab"
                  try:
                      self._f = open(self.output_path, mode)
                      self._closed = False
                      self._emit_log(f"opened:{self.output_path} mode:{mode}")
                  except Exception as e:
                      self._emit_log(f"error_open:{e}")

          def _finalize_file(self, trim=True):
              with self._lock:
                  if self._closed:
                      return
                  try:
                      if self._f:
                          self._f.flush()
                          self._f.close()
                          self._f = None
                      if trim and os.path.exists(self.output_path):
                          # trim trailing 0x00 bytes added as padding
                          with open(self.output_path, "rb") as f:
                              data = f.read()
                          data = data.rstrip(b"\x00")
                          with open(self.output_path, "wb") as f:
                              f.write(data)
                      self._closed = True
                      self._emit_log("closed")
                  except Exception as e:
                      self._emit_log(f"error_close:{e}")

          # ---------- message handlers ----------
          def _handle_ctrl(self, pdu):
              # CTRL payloads: b"RESET", b"FLUSH", b"CLOSE"
              if not pmt.is_pair(pdu): return
              pl = pmt.cdr(pdu)
              if not pmt.is_u8vector(pl): return
              cmd = bytes(pmt.u8vector_elements(pl)).strip().upper()
              if cmd == b"RESET":
                  # truncate and reset seq tracking
                  self._finalize_file(trim=False)
                  # reopen fresh (overwrite)
                  self.overwrite = True
                  self._open_file()
                  self._last_written_seq = None
                  self._emit_log("reset")
              elif cmd == b"FLUSH":
                  # flush & trim zeros once (keeps file open by reopening append)
                  self._finalize_file(trim=True)
                  self.overwrite = False
                  self._open_file()
                  self._emit_log("flushed")
              elif cmd == b"CLOSE":
                  self._finalize_file(trim=True)
              else:
                  self._emit_log(f"unknown_ctrl:{cmd!r}")

          def _handle_in(self, pdu):
              if not pmt.is_pair(pdu):
                  return
              meta, pl = pmt.car(pdu), pmt.cdr(pdu)
              if not pmt.is_u8vector(pl):
                  return
              payload = bytes(pmt.u8vector_elements(pl))

              # Expect exactly 32 bytes from crc32_verify_and_ack.out
              if len(payload) != 32:
                  self._emit_log(f"warn_len:{len(payload)} (expected 32)")

              # Read seq from metadata if present
              seq = None
              if pmt.is_dict(meta):
                  try:
                      if pmt.dict_has_key(meta, pmt.intern("seq")):
                          seq = int(pmt.to_python(pmt.dict_ref(meta, pmt.intern("seq"), pmt.PMT_NIL))) & 0xFF
                  except Exception:
                      seq = None

              # Duplicate protection (stop-and-wait should avoid dupes, but retries might echo)
              if seq is not None and self._last_written_seq is not None and seq == self._last_written_seq:
                  self._emit_log(f"skip_dup_seq:{seq}")
                  return

              # Append payload bytes
              with self._lock:
                  if not self._f:
                      self._open_file()
                  try:
                      self._f.write(payload)
                      self._f.flush()
                      self._last_written_seq = seq if seq is not None else self._last_written_seq
                  except Exception as e:
                      self._emit_log(f"error_write:{e}")
                      return

              # Light sequencing check (optional)
              if seq is not None:
                  if seq != self.expect_seq:
                      self._emit_log(f"seq_out_of_order:got={seq} exp={self.expect_seq}")
                      # still accept; update expected next (stop-and-wait increments by 1)
                  self.expect_seq = (seq + 1) & 0xFF

          # ---------- log helper ----------
          def _emit_log(self, msg: str):
              try:
                  m = pmt.make_dict()
                  m = pmt.dict_add(m, pmt.intern("file"), pmt.intern(self.output_path))
                  m = pmt.dict_add(m, pmt.intern("event"), pmt.intern(msg))
                  self.message_port_pub(pmt.intern('log'), pmt.cons(m, pmt.PMT_NIL))
              except Exception:
                  pass
    expect_seq_start: '0'
    output_path: '"C:\\Users\\Lenovo\\Downloads\\test_1\\output.txt"'
    overwrite: '1'
    strip_zeros_on_close: '1'
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt

      class ack_address_filter_rx(gr.basic_block):
          """
          ACK Address Filter (RX) with Preamble
          -------------------------------------
          Dynamically updatable via 'config' message port.

          Input PDU payload contains one or more concatenated ACK frames.

          New ACK frame format (78 bytes):
              [ PREAMBLE(32) | DEST(1) | NEXT_SEQ(1) | PAYLOAD(40) | CRC32(4) ]

          On match (DEST == my_addr):
              Output stripped ACK (45 bytes):
                 payload = [ NEXT_SEQ(1) | PAYLOAD(40) | CRC32(4) ]
                 meta    = { dest_addr=<>, next_seq=<>, ... }

          On mismatch:
              Output to 'drop' with reason 'addr_mismatch'

          Any trailing bytes < FRAME_LEN are ignored.
          """

          def __init__(self, preamble_len=32):
              gr.basic_block.__init__(self, name="Address Filter ACK",
                                      in_sig=None, out_sig=None)

              self.my_addr = 0 & 0xFF
              self.PREAMBLE_LEN = int(preamble_len)

              # Frame (per ACK) = PREAMBLE(32) + DEST(1) + NEXT_SEQ(1) + PAYLOAD(40) + CRC32(4)
              self.FRAME_LEN = self.PREAMBLE_LEN + 1 + 1 + 40 + 4  # 32 + 46 = 78

              # Standard ports
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))   # stripped ACK frames
              self.message_port_register_out(pmt.intern('drop'))  # non-matching or errors

              # NEW: Config port
              self.message_port_register_in(pmt.intern('config'))

              # Handlers
              self.set_msg_handler(pmt.intern('in'), self._handle)
              self.set_msg_handler(pmt.intern('config'), self.handle_config)

          def handle_config(self, msg):
              """ Update 'My Address' dynamically from GUI """
              # When receiving ACKs, we check if they are sent TO us.
              # So we update 'my_addr' to match our current ID.
              if pmt.is_dict(msg) and pmt.dict_has_key(msg, pmt.intern("my_addr")):
                  new_addr = pmt.to_long(pmt.dict_ref(msg, pmt.intern("my_addr"), pmt.PMT_NIL))
                  self.my_addr = new_addr & 0xFF

          def _handle(self, pdu):
              if not pmt.is_pair(pdu):
                  return
              meta, pl = pmt.car(pdu), pmt.cdr(pdu)

              if not pmt.is_u8vector(pl):
                  return

              data = list(pmt.u8vector_elements(pl))
              n = len(data)

              if n < self.FRAME_LEN:
                  self._emit_drop(meta, data, "short_input")
                  return

              # Ignore trailing partial frames
              last = n - (n % self.FRAME_LEN)

              for i in range(0, last, self.FRAME_LEN):
                  frame = data[i:i + self.FRAME_LEN]  # one full ACK frame

                  # DEST is right after the preamble
                  dest = frame[self.PREAMBLE_LEN]

                  # CHECK ADDRESS (using dynamic self.my_addr)
                  if dest != self.my_addr:
                      self._emit_drop(meta, frame, "addr_mismatch", dest_seen=dest)
                      continue

                  # Strip PREAMBLE + DEST → keep [ NEXT_SEQ | PAYLOAD(40) | CRC32(4) ] = 45 bytes
                  stripped = frame[self.PREAMBLE_LEN + 1:]

                  if len(stripped) < 1 + 40 + 4:
                      self._emit_drop(meta, frame, "short_after_strip", dest_seen=dest)
                      continue

                  next_seq = stripped[0]

                  out_meta = meta
                  try:
                      out_meta = pmt.dict_add(out_meta, pmt.intern("dest_addr"),
                                              pmt.from_long(int(dest)))
                      out_meta = pmt.dict_add(out_meta, pmt.intern("next_seq"),
                                              pmt.from_long(int(next_seq)))
                  except Exception:
                      pass

                  self.message_port_pub(
                      pmt.intern('out'),
                      pmt.cons(out_meta, pmt.init_u8vector(len(stripped), stripped))
                  )

          def _emit_drop(self, meta, bytes_list, reason, dest_seen=None):
              try:
                  m = pmt.dict_add(meta, pmt.intern("drop_reason"),
                                   pmt.intern(str(reason)))
                  if dest_seen is not None:
                      m = pmt.dict_add(m, pmt.intern("dest_seen"),
                                       pmt.from_long(int(dest_seen)))
                  v = pmt.init_u8vector(len(bytes_list), bytes_list)
                  self.message_port_pub(pmt.intern('drop'), pmt.cons(m, v))
              except Exception:
                  pass
    preamble_len: '128'
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES

      class pdu_aes_decrypt(gr.basic_block):
          """
          PDU AES Decrypt (AES-CTR)

          In:
            - PDU: (meta, payload_bytes)
                   payload = NONCE(8 bytes) | CIPHERTEXT

          Out:
            - PDU: same meta
                   payload = PLAINTEXT

          Parameters:
            key_hex : same key as encrypt block
            verbose : print debug
          """

          def __init__(self, key_hex="00112233445566778899AABBCCDDEEFF", verbose=True):
              gr.basic_block.__init__(self,
                                      name="PDU AES Decrypt (CTR)",
                                      in_sig=None,
                                      out_sig=None)

              self.verbose = bool(verbose)
              self.set_key_hex(key_hex)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self._handle_msg)

          def _log(self, msg):
              if self.verbose:
                  print(f"[pdu_aes_decrypt] {msg}")

          # ---- key handling ----
          def set_key_hex(self, key_hex):
              key_hex = key_hex.replace(" ", "")
              try:
                  key = bytes.fromhex(key_hex)
              except ValueError:
                  raise ValueError("key_hex must be valid hex")

              if len(key) not in (16, 24, 32):
                  raise ValueError("AES key must be 16, 24, or 32 bytes (32/48/64 hex chars)")

              self._key = key
              self._log(f"Key set ({len(key)} bytes)")

          # ---- message handler ----
          def _handle_msg(self, pdu):
              if not pmt.is_pair(pdu):
                  return

              meta = pmt.car(pdu)
              pl   = pmt.cdr(pdu)

              if not pmt.is_u8vector(pl):
                  self._log("Ignoring non-u8vector payload")
                  return

              data = bytes(pmt.u8vector_elements(pl))
              if len(data) < 8:
                  self._log("Payload too short (no nonce)")
                  return

              nonce = data[:8]
              ciphertext = data[8:]

              cipher = AES.new(self._key, AES.MODE_CTR, nonce=nonce)
              plaintext = cipher.decrypt(ciphertext)

              payload_pmt = pmt.init_u8vector(len(plaintext), list(plaintext))
              out_pdu = pmt.cons(meta, payload_pmt)
              self.message_port_pub(pmt.intern("out"), out_pdu)

              self._log(f"Decrypted PDU: in_len={len(data)}, out_len={len(plaintext)}")
    key_hex: aes_key
    verbose: 'False'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"AFTER SYNC"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"ACK"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: ''
    size: '64'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: r4
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: out1
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ack_tx
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: r3
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: ack
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: soapy_sink
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: msg_out
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: config
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: soapy_sink
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: r3
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: r4
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: out1
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: ack_tx
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: ack
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: msg_out
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: ack
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: config
  states: {}
- name: virtual_source_8_0
  id: virtual_source
  parameters:
    stream_id: config
  states: {}
- name: virtual_source_8_1
  id: virtual_source
  parameters:
    stream_id: config
  states: {}
- name: virtual_source_8_1_0
  id: virtual_source
  parameters:
    stream_id: config
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_1, '0']
- [blocks_repack_bits_bb_0_0, '0', virtual_sink_1_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_2, '0']
- [blocks_throttle2_1, '0', virtual_sink_5, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_append_0, out, epy_block_0_0, in]
- [digital_crc_append_0_0, out, epy_block_1_0, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0_1, '0']
- [digital_linear_equalizer_0_0, '0', virtual_sink_3, '0']
- [digital_map_bb_0, '0', virtual_sink_0_1_0, '0']
- [digital_map_bb_0_0, '0', virtual_sink_0_1_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [epy_block_0_0, out, digital_protocol_formatter_async_0, in]
- [epy_block_0_1, config_out, virtual_sink_7, '0']
- [epy_block_0_1, out, epy_block_4, in]
- [epy_block_10, out, digital_crc_append_0, in]
- [epy_block_11, ack_out, digital_crc_append_0_0, in]
- [epy_block_11, out, epy_block_8, in]
- [epy_block_12, ack_out, virtual_sink_4, '0']
- [epy_block_1_0, out, digital_protocol_formatter_async_0_0, in]
- [epy_block_2, out, epy_block_11, in]
- [epy_block_4, out, epy_block_10, in]
- [epy_block_6, out, blocks_message_debug_0, print]
- [epy_block_6, out, epy_block_12, in]
- [epy_block_8, out, epy_block_5, in]
- [epy_block_8, out, virtual_sink_6, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_2, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_6, in]
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_1_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_2, '0', pdu_tagged_stream_to_pdu_0, '0']
- [virtual_source_2_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [virtual_source_3, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_4, '0', epy_block_10, ack_in]
- [virtual_source_5, '0', epy_block_0_1, in]
- [virtual_source_6, '0', epy_block_0_1, ack_in]
- [virtual_source_7, '0', epy_block_0_0, config]
- [virtual_source_8_0, '0', epy_block_1_0, config]
- [virtual_source_8_1, '0', epy_block_2, config]
- [virtual_source_8_1_0, '0', epy_block_6, config]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
